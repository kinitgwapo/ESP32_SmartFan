## sdkconfig.defaults
```kconfig
CONFIG_ESP_PROTOCOMM_SUPPORT_SECURITY_VERSION_1=y

CONFIG_MBEDTLS_CERTIFICATE_BUNDLE=y

CONFIG_MBEDTLS_CERTIFICATE_BUNDLE_CROSS_SIGNED_VERIFY=y
```
